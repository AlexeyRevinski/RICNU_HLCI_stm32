# IAR project Project.ewp, settings and files
configuration STM32L152RC (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RC ST STM32L152RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MDP; BOARD_TYPE_FLEXSEA_PLAN
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\Libraries\FatFs\source; ..\..\Libraries\cJSON; ..\..\Libraries\jsmn; ..\inc; ..\..\..\..\FlexSEA\inc; ..\..\..\..\FlexSEA\flexsea-comm\inc; ..\..\..\..\FlexSEA\flexsea-system\inc; ..\..\..\..\FlexSEA\flexsea-user\inc; ..\..\..\..\FlexSEA\flexsea-user\RICNU_Knee_v1\inc; ..\..\..\..\FlexSEA\flexsea-user\MIT_2DoF_Ankle_v1\inc; ..\..\..\..\FlexSEA\flexsea-user\MotorTestBench\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L1XX_MDP.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: Project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../src/: system_stm32l1xx.c
  group EWARM
    ../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_mdp.s
  group FatFs
    ../../Libraries/FatFs/source/: diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c integer.h
  group FLEXSEA/flexsea-comm/inc
    ../../../../FlexSEA/flexsea-comm/inc/: flexsea.h flexsea_buffers.h flexsea_circular_buffer.h flexsea_comm.h flexsea_comm_def.h flexsea_payload.h
  group FLEXSEA/flexsea-comm/src
    ../../../../FlexSEA/flexsea-comm/src/: flexsea.c flexsea_buffers.c flexsea_circular_buffer.c flexsea_comm.c flexsea_payload.c
  group FLEXSEA/flexsea-system/inc
    ../../../../FlexSEA/flexsea-system/inc/: flexsea_cmd_calibration.h flexsea_cmd_control.h flexsea_cmd_data.h flexsea_cmd_external.h flexsea_cmd_in_control.h flexsea_cmd_sensors.h flexsea_cmd_stream.h flexsea_cmd_tools.h flexsea_dataformats.h flexsea_global_structs.h flexsea_sys_def.h flexsea_system.h
  group FLEXSEA/flexsea-system/src
    ../../../../FlexSEA/flexsea-system/src/: flexsea_cmd_calibration.c flexsea_cmd_control_1.c flexsea_cmd_control_2.c flexsea_cmd_data.c flexsea_cmd_external.c flexsea_cmd_in_control.c flexsea_cmd_sensors.c flexsea_cmd_stream.c flexsea_cmd_tools.c flexsea_global_structs.c flexsea_system.c
  group FLEXSEA/flexsea-user/inc
    ../../../../FlexSEA/flexsea-user/inc/: dynamic_user_structs.h flexsea_cmd_user.h flexsea_user_structs.h
  group FLEXSEA/flexsea-user/MIT_2DoF_Ankle_v1/inc
    ../../../../FlexSEA/flexsea-user/MIT_2DoF_Ankle_v1/inc/: cmd-MIT_2DoF_Ankle_v1.h
  group FLEXSEA/flexsea-user/MIT_2DoF_Ankle_v1/src
    ../../../../FlexSEA/flexsea-user/MIT_2DoF_Ankle_v1/src/: cmd-MIT_2DoF_Ankle_v1.c
  group FLEXSEA/flexsea-user/MotorTestBench/inc
    ../../../../FlexSEA/flexsea-user/MotorTestBench/inc/: cmd-MotorTestBench.h
  group FLEXSEA/flexsea-user/MotorTestBench/src
    ../../../../FlexSEA/flexsea-user/MotorTestBench/src/: cmd-MotorTestBench.c
  group FLEXSEA/flexsea-user/RICNU_Knee_v1/inc
    ../../../../FlexSEA/flexsea-user/RICNU_Knee_v1/inc/: cmd-RICNU_Knee_v1.h
  group FLEXSEA/flexsea-user/RICNU_Knee_v1/src
    ../../../../FlexSEA/flexsea-user/RICNU_Knee_v1/src/: cmd-RICNU_Knee_v1.c
  group FLEXSEA/flexsea-user/src
    ../../../../FlexSEA/flexsea-user/src/: dynamic_user_structs_common.c dynamic_user_structs_plan.c flexsea_cmd_user.c flexsea_user_structs.c
  group jsmn
    ../../Libraries/jsmn/: jsmn.c jsmn.h
  group StdPeriph_Driver
    ../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
  group User/inc
    ../inc/: flexsea_board.h plan_comm.h plan_config.h plan_fsm_builder.h plan_include.h plan_led.h plan_sd.h plan_state_system.h plan_utilities.h stm32l1xx_conf.h stm32l1xx_it.h
  group User/src
    ../src/: flexsea_board.c main.c plan_comm.c plan_config.c plan_fatfs.c plan_fsm_builder.c plan_led.c plan_sd.c plan_state_system.c plan_utilities.c stm32l1xx_it.c
